FILESEXTRAPATHS:prepend := "${THISDIR}/everest-core:"

SRC_URI += "file://0001-install-everest_staging_helpers.patch"