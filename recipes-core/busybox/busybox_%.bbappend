EXTRA_OECONF:append = " --enable-feature-udhcp --enable-udhcpc"
